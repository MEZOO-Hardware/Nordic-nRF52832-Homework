# Keil uVision project nRF52832_Template.uvprojx, settings and files
target nRF52832_Template (5060960::V5.06 update 7 (build 960)::.\ARM_Compiler_5.06u7)
  device: nRF52832_xxAA Nordic Semiconductor
  pack: NordicSemiconductor.nRF_DeviceFamilyPack.8.44.1
  cpu: IRAM(0x20000000,0x00010000) IRAM2(0x00800000,0x00010000) IROM(0x00000000,0x00080000) CPUTYPE("Cortex-M4") FPU2 DSP CLOCK(12000000) ELITTLE
  output: nRF52832_Template +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=1
  c define: APP_TIMER_V2 APP_TIMER_V2_RTC1_ENABLED BOARD_PCA10040 BSP_DEFINES_ONLY CONFIG_GPIO_AS_PINRESET FLOAT_ABI_HARD NRF52 NRF52832_XXAA NRF52_PAN_74 __HEAP_SIZE=8192 __STACK_SIZE=8192
  c include: ..\nRF5_SDK_17.1.0_ddde560\config\nrf52832\config;..\nRF5_SDK_17.1.0_ddde560\components;..\nRF5_SDK_17.1.0_ddde560\components\boards;..\nRF5_SDK_17.1.0_ddde560\components\libraries\log\src;..\nRF5_SDK_17.1.0_ddde560\components\libraries\atomic;..\nRF5_SDK_17.1.0_ddde560\components\libraries\balloc;..\nRF5_SDK_17.1.0_ddde560\components\libraries\bsp;..\nRF5_SDK_17.1.0_ddde560\components\libraries\delay;..\nRF5_SDK_17.1.0_ddde560\components\libraries\experimental_section_vars;..\nRF5_SDK_17.1.0_ddde560\components\libraries\log;..\nRF5_SDK_17.1.0_ddde560\components\libraries\log\src;..\nRF5_SDK_17.1.0_ddde560\components\libraries\memobj;..\nRF5_SDK_17.1.0_ddde560\components\libraries\ringbuf;..\nRF5_SDK_17.1.0_ddde560\components\libraries\strerror;..\nRF5_SDK_17.1.0_ddde560\components\libraries\util;..\nRF5_SDK_17.1.0_ddde560\components\libraries\pwr_mgmt;..\nRF5_SDK_17.1.0_ddde560\components\libraries\pwm;..\nRF5_SDK_17.1.0_ddde560\components\libraries\mutex;..\nRF5_SDK_17.1.0_ddde560\components\libraries\bsp;..\nRF5_SDK_17.1.0_ddde560\components\libraries\low_power_pwm;..\nRF5_SDK_17.1.0_ddde560\components\libraries\timer;..\nRF5_SDK_17.1.0_ddde560\components\libraries\uart;..\nRF5_SDK_17.1.0_ddde560\components\libraries\fifo;..\nRF5_SDK_17.1.0_ddde560\components\libraries\atomic_fifo;..\nRF5_SDK_17.1.0_ddde560\components\libraries\sortlist;..\nRF5_SDK_17.1.0_ddde560\components\drivers_nrf\nrf_soc_nosd;..\nRF5_SDK_17.1.0_ddde560\external\fprintf;..\nRF5_SDK_17.1.0_ddde560\external\segger_rtt;..\nRF5_SDK_17.1.0_ddde560\integration\nrfx;..\nRF5_SDK_17.1.0_ddde560\integration\nrfx\legacy;..\nRF5_SDK_17.1.0_ddde560\modules\nrfx;..\nRF5_SDK_17.1.0_ddde560\modules\nrfx\hal;..\nRF5_SDK_17.1.0_ddde560\modules\nrfx\soc;..\nRF5_SDK_17.1.0_ddde560\modules\nrfx\drivers\src;..\nRF5_SDK_17.1.0_ddde560\modules\nrfx\drivers\src\prs;..\nRF5_SDK_17.1.0_ddde560\modules\nrfx\drivers\include;Project\api;Project\app;Project\sys;Project\protocol;Project\filter
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  memory RVCT10: RAM 0x800000 size 0x10000
  link misc: --diag_suppress 6330
  group Application
    ./: main.c
    ../nRF5_SDK_17.1.0_ddde560/config/nrf52832/config/: sdk_config.h
  group Board Definiton
    ../nRF5_SDK_17.1.0_ddde560/components/boards/: boards.c
  group nRF_Drivers
    ../nRF5_SDK_17.1.0_ddde560/integration/nrfx/legacy/: nrf_drv_ppi.c nrf_drv_twi.c nrf_drv_uart.c nrf_drv_spi.c
    ../nRF5_SDK_17.1.0_ddde560/modules/nrfx/soc/: nrfx_atomic.c
    ../nRF5_SDK_17.1.0_ddde560/modules/nrfx/drivers/src/: nrfx_gpiote.c nrfx_ppi.c nrfx_timer.c nrfx_twi.c nrfx_twim.c nrfx_uarte.c nrfx_uart.c nrfx_saadc.c nrfx_spi.c nrfx_spim.c
    ../nRF5_SDK_17.1.0_ddde560/modules/nrfx/drivers/src/prs/: nrfx_prs.c
    ../nRF5_SDK_17.1.0_ddde560/components/drivers_nrf/nrf_soc_nosd/: nrf_nvic.c nrf_soc.c
  group nRF_Libraries
    ../nRF5_SDK_17.1.0_ddde560/components/libraries/util/: app_error.c app_error_handler_keil.c app_error_weak.c app_util_platform.c nrf_assert.c
    ../nRF5_SDK_17.1.0_ddde560/components/libraries/atomic/: nrf_atomic.c
    ../nRF5_SDK_17.1.0_ddde560/components/libraries/balloc/: nrf_balloc.c
    ../nRF5_SDK_17.1.0_ddde560/external/fprintf/: nrf_fprintf.c nrf_fprintf_format.c
    ../nRF5_SDK_17.1.0_ddde560/components/libraries/memobj/: nrf_memobj.c
    ../nRF5_SDK_17.1.0_ddde560/components/libraries/pwr_mgmt/: nrf_pwr_mgmt.c
    ../nRF5_SDK_17.1.0_ddde560/components/libraries/ringbuf/: nrf_ringbuf.c
    ../nRF5_SDK_17.1.0_ddde560/components/libraries/experimental_section_vars/: nrf_section_iter.c
    ../nRF5_SDK_17.1.0_ddde560/components/libraries/strerror/: nrf_strerror.c
    ../nRF5_SDK_17.1.0_ddde560/components/libraries/fifo/: app_fifo.c
    ../nRF5_SDK_17.1.0_ddde560/components/libraries/uart/: app_uart_fifo.c retarget.c
    ../nRF5_SDK_17.1.0_ddde560/components/libraries/button/: app_button.c
    ../nRF5_SDK_17.1.0_ddde560/components/libraries/scheduler/: app_scheduler.c
    ../nRF5_SDK_17.1.0_ddde560/components/libraries/sortlist/: nrf_sortlist.c
    ../nRF5_SDK_17.1.0_ddde560/components/libraries/timer/: app_timer2.c drv_rtc.c
    ../nRF5_SDK_17.1.0_ddde560/components/libraries/atomic_fifo/: nrf_atfifo.c
  group nRF_Log
    ../nRF5_SDK_17.1.0_ddde560/components/libraries/log/src/: nrf_log_backend_rtt.c nrf_log_backend_serial.c nrf_log_backend_uart.c nrf_log_default_backends.c nrf_log_frontend.c nrf_log_str_formatter.c
  group nRF_Segger_RTT
    ../nRF5_SDK_17.1.0_ddde560/external/segger_rtt/: SEGGER_RTT.c SEGGER_RTT_Syscalls_KEIL.c SEGGER_RTT_printf.c
  group Project\app
    ./Project/app/: app.h
    ./Project/app/bma400/: bma400.c bma400.h
  group Project\api
    ./Project/api/: api.h
    ./Project/api/i2c/: i2c.c
    ./Project/api/spi/: spi.c
    ./Project/api/uart/: uart.c
    ./Project/api/rtt/: rtt.c
    ./Project/api/adc/: adc.c
    ./Project/api/port/: port.c
  group Project\sys
    ./Project/sys/: headerfile.h sys.h
    ./Project/sys/timeInterrupt/: timeInterrupt.c
    ./Project/sys/pinChangeInterrupt/: pinChangeInterrupt.c
  group Project\protocol
    ./Project/protocol/: protocol.h
  group Project\filter
    ./Project/filter/: filter.h
software components: CMSIS:CORE 5.6.0, Device:Startup 8.44.1
